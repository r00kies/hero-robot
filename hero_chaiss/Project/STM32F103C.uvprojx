# Keil uVision project STM32F103C.uvprojx, settings and files
target STM32F103C8T6 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Mylib;..\Libraries;..\CM3;..\User;..\User\debug
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CM3
    ../CM3/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group Libraries
    ../Libraries/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_iwdg.c
  group Mylib
    ../Mylib/: led.c encoder.c pwm.c can.c delay.c ad.c flash.c key.c Iwdg.c DEBUG.c control.c UART.c tim2.c BSP.c
  group User
    ../User/: main.c stm32f10x_it.c
    ../User/debug/: DataScope_DP.C
